# Keil uVision project ITE_EC.uvproj, settings and files
target ITE_EC (MCS-51)
  device: 8031AH Intel
  cpu: IRAM(0-0x7F) CLOCK(12000000)
  output: ITEEC +hex
  BeforeMake: GetTime.bat
  AfterMake: MakeUp.bat
  AfterMake: MakeUefi.bat
  c flags: Optimize=9
  c include: ..\Code\CORE\INCLUDE\;..\Code\OEM\OEM\INCLUDE\;..\Code\CHIP\INCLUDE\;..\Code\API\INCLUDE\
  group API_COMMON
    ../Code/API/: API_ADC.C API_DAC.C API_ETWD.C API_GPIO.C API_I2C_SLAVE.C API_INTC.C API_OW.C API_PECI.C API_PWM.C API_SHA1.C API_SMBUS_SLAVE.C API_SSPI.C API_WUC.C
  group API_INCLUDE
    ../Code/API/INCLUDE/: API_ADC.H API_DAC.H API_ETWD.H API_GPIO.H API_I2C_SLAVE.H API_INCLUDE.H API_INTC.H API_OW.H API_PECI.H API_PWM.H API_SHA1.H API_SMBUS_SLAVE.H API_SSPI.H API_WUC.H
  group CORE_COMMON
    ../Code/CORE/CORE_COMMON/: CORE_ACPI.C CORE_ASM.C CORE_BITADDR.C CORE_GPIO.C CORE_HOSTIF.C CORE_INIT.C CORE_IRQ.C CORE_MAIN.C CORE_Memory.C CORE_PORT6064.C CORE_SMBUS.C CORE_TIMERS.C L51_BANK.A51 STARTUP.A51
    ../Code/CHIP/: CORE_CHIPREGS.C CORE_ITEString.C
  group CORE_BANK0
    ../Code/CORE/CORE_BANK0/: CORE_FLASH.C CORE_PS2.C CORE_SCAN.C CORE_XLT.C
  group CORE_INCLUDE
    ../Code/CHIP/INCLUDE/: CORE_CHIPREGS.H CORE_CHIPSFR.H
    ../Code/CORE/INCLUDE/: CORE_ACPI.H CORE_ASM.H CORE_BITADDR.H CORE_FLASH.H CORE_GPIO.H CORE_HOSTIF.H CORE_INCLUDE.H CORE_INIT.H CORE_IRQ.H CORE_MAIN.H CORE_Memory.H CORE_PORT6064.H CORE_PS2.H CORE_SCAN.H CORE_SMBUS.H CORE_TIMERS.H CORE_TYPES.H CORE_XLT.H
  group OEM_BANK1
    ../Code/OEM/OEM/OEM_BANK1/: OEM_BANK1_Func.C
  group OEM_BANK2
    ../Code/OEM/OEM/OEM_BANK2/: OEM_BANK2_Func.C
  group OEM_BANK3
    ../Code/OEM/OEM/OEM_BANK3/: OEM_BANK3_Func.C
  group OEM_INCLUDE
    ../Code/OEM/OEM/INCLUDE/: OEM_6064.H OEM_ACPI.H OEM_ADC.H OEM_ASM.H OEM_BANK1_Func.H OEM_BANK2_Func.H OEM_BANK3_Func.H OEM_BATTERY.H OEM_CIR.H OEM_Debug.H OEM_ECPDM.H OEM_EVENT.H OEM_FAN.H OEM_FLASH.H OEM_GPIO.H OEM_HOSTIF.H OEM_HSPI.H OEM_INCLUDE.H OEM_INIT.H OEM_IRQ.H OEM_LCD.H OEM_LED.H OEM_LPC.H OEM_MailBox.H OEM_MAIN.H OEM_MEMORY.H OEM_MMB.H OEM_PECI.H OEM_PM2.H OEM_PM3.H OEM_PM4.H OEM_POWER.H OEM_Project.H OEM_PS2.H OEM_SCANTABS.H OEM_SMBUS.H OEM_SPI.H OEM_TIMER.H OEM_Ver.H OEM_TIME.H
  group OEM_BANK0
    ../Code/OEM/OEM/OEM_BANK0/: OEM_6064.C OEM_ACPI.C OEM_ADC.C OEM_ASM.C OEM_BATTERY.C OEM_CIR.C OEM_Debug.C OEM_ECPDM.C OEM_EVENT.C OEM_FAN.C OEM_FLASH.C OEM_GPIO.C OEM_HOSTIF.C OEM_HSPI.C OEM_INIT.C OEM_IRQ.C OEM_LCD.C OEM_LED.C OEM_LPC.C OEM_MailBox.C OEM_MAIN.C OEM_MEMORY.C OEM_MMB.C OEM_PECI.C OEM_PM2.C OEM_PM3.C OEM_PORT686C.C OEM_POWER.C OEM_PS2.C OEM_SCANTABS.C OEM_SMBUS.C OEM_SPI.C OEM_TIMER.C OEM_Ver.C
  group USBC_PD
    ../Code/OEM/OEM/USBC_PD/Cypress/: UCSI_CCG5.C UPD_CCG5.C UCSI_CCG5.H
